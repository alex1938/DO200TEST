# Keil uVision project SIM.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F105RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DF702_LoRa +hex
  AfterMake: fromelf --bin --output .\DO200-80V1.1.1.bin .\Objects\DF702_LoRa.axf
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_CL
  c include: ..\CORE;..\HARDWARE;..\Protocol;..\STM32F10x_FWLib\inc;..\USER;..\SYSTEM;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT
  memory RVCT4: ROM 0x8003000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../USER/: main.c system_stm32f10x.c protocol.c calct.c
  group HARDWARE
    ../HARDWARE/: ultra.c ntc.c power.c mpuiic.c Lsm303Agr.c Lsm303Agr_driver.c nb.c
  group SYSTEM
    ../SYSTEM/: delay.c gpio.c system.c timer.c usart.c flash.c adc.c rtc.c led.c dma.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_cl.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_pwr.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_dma.c
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c
    ./: os_app.c
